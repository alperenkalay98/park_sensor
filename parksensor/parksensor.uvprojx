# Keil uVision project parksensor.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: parksensor
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: Startup.s main.s lcd_init.s initial_screen.s sw_inits.s motor_init.s adc_init.s dist_init.s sw1_detect.s dist_track.s comparison.s digit_changes.s new_convrts.s mode_cursors.s prog_bar_curs.s modify_prog_bar.s delayer.s sw2_detect.s
